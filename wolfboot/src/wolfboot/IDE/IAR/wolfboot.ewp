# IAR project wolfboot.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __WOLFBOOT; PLATFORM_stm32f4; ARCH_ARM; WOLFSSL_USER_SETTINGS; DEBUG_CONSOLE_ASSERT_DISABLE=1; WOLFBOOT_SIGN_ECC256; WOLFBOOT_HASH_SHA256; WOLFSSL_SP_ASM; WOLFSSL_SP_ARM_CORTEX_M_ASM
  ICCARM.CCIncludePath2: ..\..\include; ..\..\lib\wolfssl; ..\..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: wolfboot.bin
  ILINK.IlinkOutputFile: wolfboot.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group hal
    ../../hal/: stm32f4.c
  group hal/spi
    ../../include/: spi_drv.h
  group include
    ../../include/: hal.h image.h loader.h printf.h target.h user_settings.h
  group include/wolfboot
    ../../include/wolfboot/: wolfboot.h
  group lib/wolfcrypt
    ../../lib/wolfssl/wolfcrypt/src/: ecc.c hash.c memory.c sha.c sha256.c sp_cortexm.c sp_int.c wc_port.c
  group src
    ../../src/: boot_arm.c ecc256_pub_key.c image.c libwolfboot.c loader.c string.c update_flash.c xmalloc_ecc.c
